<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polarcode_complete</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbChuncks</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbStrgUsers</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbWeakUsers</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nbfiles</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code_rate</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>id_user</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlength</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>digital.constellation_qpsk()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>size_chunk</value></param>
<param><key>value</key><value>42</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>small_packet_len</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variance</value></param>
<param><key>value</key><value>1/pow(10,snr/10.0)</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>numpy.sqrt(variance)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>numpy.random.randint(0,500,None)</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>3000</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packetlength</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>display</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_1</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>payload_mod.points()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>projectCACHE_PolarDec_b</key>
<param><key>id</key><value>projectCACHE_PolarDec_b_0</value></param>
<param><key>size_chunk</key><value>size_chunk</value></param>
<param><key>code_rate</key><value>code_rate</value></param>
<param><key>N</key><value>N</value></param>
<param><key>b_chunks</key><value>NbChuncks</value></param>
<param><key>m_files</key><value>Nbfiles</value></param>
<param><key>n_users</key><value>NbWeakUsers</value></param>
<param><key>lengthtagname</key><value>packetlength</value></param>
<param><key>id_user</key><value>id_user</value></param>
<param><key>spack_len</key><value>small_packet_len</value></param>
</block>
<block>
<key>projectCACHE_map_header_payload_bc</key>
<param><key>id</key><value>projectCACHE_map_header_payload_bc_0</value></param>
<param><key>hx_gain</key><value>2</value></param>
<param><key>lengthtagname</key><value>packetlength</value></param>
<param><key>payload_maptype</key><value>2</value></param>
</block>
<block>
<key>projectCACHE_polarEnc_b</key>
<param><key>id</key><value>projectCACHE_polarEnc_b_0</value></param>
<param><key>c_rate</key><value>[1,2,3,4]</value></param>
<param><key>N</key><value>N</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>NbStrg</key><value>NbStrgUsers</value></param>
<param><key>chuncks</key><value>NbChuncks</value></param>
<param><key>files</key><value>Nbfiles</value></param>
<param><key>spack_len</key><value>small_packet_len</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>projectCACHE_PolarDec_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>projectCACHE_map_header_payload_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_map_header_payload_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_map_header_payload_bc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>projectCACHE_map_header_payload_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
