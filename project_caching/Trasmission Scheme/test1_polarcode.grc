<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polarcode_complete</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ks</value></param>
<param><key>value</key><value>2*Kw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kw</value></param>
<param><key>value</key><value>70*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbChuncks</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbStrgUsers</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nbfiles</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>boost</value></param>
<param><key>value</key><value>20*numpy.log10(4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>value</key><value>digital.constellation_bpsk()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>id_user</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_users</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlength</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>value</key><value>digital.constellation_qpsk()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>small_packet_len</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>boost + 15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variance</value></param>
<param><key>value</key><value>1/pow(10,snr/10.0)</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>numpy.sqrt(variance)</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>numpy.random.randint(0,500,None)</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packetlength</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>payload_mod.points()</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>alpha</key><value>0.00001</value></param>
<param><key>msg_nsamples</key><value>2000</value></param>
<param><key>type</key><value>3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>projectCACHE_PC_Error_Rate</key>
<param><key>id</key><value>projectCACHE_PC_Error_Rate_0</value></param>
</block>
<block>
<key>projectCACHE_PolarDec_b</key>
<param><key>id</key><value>projectCACHE_PolarDec_b_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>comment</key><value>Nb_users = Nb_users_weak</value></param>
<param><key>b_chunks</key><value>NbChuncks</value></param>
<param><key>m_files</key><value>Nbfiles</value></param>
<param><key>n_users</key><value>n_users</value></param>
<param><key>lengthtagname</key><value>packetlength</value></param>
<param><key>K_s</key><value>Ks</value></param>
<param><key>id_user</key><value>id_user</value></param>
<param><key>K_w</key><value>Kw</value></param>
<param><key>spack_len</key><value>small_packet_len</value></param>
</block>
<block>
<key>projectCACHE_map_header_payload_bc</key>
<param><key>id</key><value>projectCACHE_map_header_payload_bc_0</value></param>
<param><key>hx_maptype</key><value>0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>payload_maptype</key><value>0</value></param>
</block>
<block>
<key>projectCACHE_polarEnc_b</key>
<param><key>id</key><value>projectCACHE_polarEnc_b_0</value></param>
<param><key>N</key><value>N</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>NbStrg</key><value>NbStrgUsers</value></param>
<param><key>chuncks</key><value>NbChuncks</value></param>
<param><key>files</key><value>Nbfiles</value></param>
<param><key>spack_len</key><value>small_packet_len</value></param>
<param><key>K_s</key><value>Ks</value></param>
<param><key>id_user</key><value>id_user</value></param>
<param><key>K_w</key><value>Kw</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate*8</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>int(1000000*.5)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>projectCACHE_PolarDec_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>snr</source_key><sink_key>SNR</sink_key></connection>
<connection><source_block_id>projectCACHE_PolarDec_b_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>RX_CW</source_key><sink_key>RX_CW</sink_key></connection>
<connection><source_block_id>projectCACHE_PolarDec_b_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>RX_MSG</source_key><sink_key>RX_MSG</sink_key></connection>
<connection><source_block_id>projectCACHE_map_header_payload_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>TX_CW</source_key><sink_key>TX_CW</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>TX_MSG</source_key><sink_key>TX_MSG</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>projectCACHE_polarEnc_b_0</source_block_id><sink_block_id>projectCACHE_map_header_payload_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
