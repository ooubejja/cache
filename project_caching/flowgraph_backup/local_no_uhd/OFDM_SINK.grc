<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>OFDM_SINK</value></param>
<param><key>author</key><value>Yasser</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Polar Coding with Coded Caching</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>projectCACHE_PC_Error_Rate</key>
<param><key>id</key><value>projectCACHE_PC_Error_Rate_0</value></param>
<param><key>is_strong</key><value>True</value></param>
<param><key>usr_id</key><value>5</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://localhost:5555</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0</value></param>
<param><key>address</key><value>tcp://localhost:5558</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_0</value></param>
<param><key>address</key><value>tcp://localhost:5560</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_0_1</value></param>
<param><key>address</key><value>tcp://localhost:5559</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_1</value></param>
<param><key>address</key><value>tcp://localhost:5557</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0_2</value></param>
<param><key>address</key><value>tcp://localhost:5556</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>TX_MSG</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>RX_CW</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_0</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>CH_USE</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_0_1</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>SNR</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_1</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>RX_MSG</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0_2</source_block_id><sink_block_id>projectCACHE_PC_Error_Rate_0</sink_block_id><source_key>out</source_key><sink_key>TX_CW</sink_key></connection>
</flow_graph>
